# Keil uVision project source_v1.uvproj, settings and files
target source (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: source_v1 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\App;.\Bsp;.\Dri;..\lib\inc;..\lib\src;..\core;.\Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/: main.c stm32f10x_it.c system_stm32f10x.c
  group Bsp
    ./Bsp/: bsp.c bsp_Tim.c
  group Public
    ./Public/: broad.h
  group FWLib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ../core/: core_cm3.c startup_stm32f10x_md.s
  group Doc
    ./Doc/: Readme.txt
  group Driver
    ./Dri/: Oled.c Car.c

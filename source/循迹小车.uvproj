# Keil uVision project 循迹小车.uvproj, settings and files
target SmartCar (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: 循迹小车 +hex
  c flags: Optimize=8 SizeSpeed=1
  group obj
    ./: STARTUP.A51 function.c main.c IR.c 1602.c control.c light_control.c remote.c ultrasonic.c dance.c wireless.c

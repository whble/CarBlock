/********************************************************************************************
**文件说明:		功能函数文件
**版权归属:		EMO--E梦电子
**创 建 人:		whble
**版    本:		1.0V
**淘	宝:		http://taobao.xiangyunzone.com
**论    坛:		http://www.honeygeek.org/
**创建日期:		2013-7-25
*********************************************************************************************
**修 改 人:
**修改说明:
**修改版本:		
********************************************************************************************/

/*********************************公共头文件************************************************/
#include "define.h"

/*********************************全局变量**************************************************/

#define  NOP()   _nop_()   /* 定义空指令 */

/********************************************************************************************
**函数名称:		void delay_ms(uint z)
**函数功能:		毫秒级延时函数
**输入参数:		Z 延时时间
**输出参数:		none
**返 回 值:		none
**创 建 人:		whble
**创建日期:		2013-7-25
*********************************************************************************************
**修 改 人:
**修改说明:
********************************************************************************************/
void delay_ms(uint z)
{
	uint x,y;
	for(x = z;x > 0;x --)
		for(y = 110;y>0;y--);
}
/********************************************************************************************
**函数名称:		void delay_20_us()
**函数功能:		微秒级延时函数
**输入参数:		none
**输出参数:		none
**返 回 值:		none
**创 建 人:		whble
**创建日期:		2013-7-25
*********************************************************************************************
**修 改 人:
**修改说明:
********************************************************************************************/	
void delay_20_us()
{
	uchar a;
	for(a = 0;a< 100;a++);
}
/********************************************************************************************
**函数名称:		void delay(unsigned char x)
**函数功能:		自定义延时函数
**输入参数:		X 延时参数
**输出参数:		none
**返 回 值:		none
**创 建 人:		whble
**创建日期:		2013-7-25
*********************************************************************************************
**修 改 人:
**修改说明:
********************************************************************************************/
void delay(unsigned char x)    //x*0.14MS
{
 unsigned char i;
 while(x--)
 {
  for (i = 0; i<13; i++) {}
 }
}

/************************毫秒延时**********************************/
void delay1(int ms)
{
 unsigned char y;
 while(ms--)
 {
  for(y = 0; y<250; y++)
  {
   _nop_();
   _nop_();
   _nop_();
   _nop_();
  }
 }
} 
